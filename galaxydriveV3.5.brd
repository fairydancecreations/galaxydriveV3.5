# Repository fairydancecreations/galaxydriveV3.5

## EAGLE design galaxydriveV3.5.brd

Parts:
C1: 22n; C5B2.5
C2: 10u; E1,8-4
C3: 100p; C5B2.5
C4: 47n; C5B2.5
C5, C9, C10, C11: 100n; C5B2.5
C6, C12: 100u; E2-4
C7: 33n; C5B2.5
C8: 4n7; C5B2.5
D1: 6v2 zener; DO34Z7
D3, D6: D9G; DO07
D4: 1n5178; D-7.5
G: 2,15/1,0
GAIN: 5k; 3RP/1610N
I: 2,15/1,0
L1: 100mH; MCC10
LEVEL: 100k; B25P
MIDS: 25k; B25P
O: 2,15/1,0
OVERGAIN: 5k; 3RP/1610N
R1, R14: 1m; 0207/7
R2: 5k1; 0207/7
R3, R10: 10m; 0207/7
R4: 4k7; 0207/7
R5, R12: 10k; 0207/7
R6: 2m2; 0207/7
R7: 15k; 0207/7
R8: 220R; 0207/7
R9: 1k; 0207/7
R11: 100k; 0207/7
R13, R15: 330R; 0207/7
T1: BS170; SOT54E
T2, T3: 2n5089; TO92
TONE: 100k; 3RP/1610N
V: 9v; 2,15/1,0

Connections:
GND: C1.2, C3.2, C6.-, C7.1, C9.1, C12.-, D3.A, D6.C, G.1, GAIN.1 (A), GAIN.2 (S), LEVEL.A, OVERGAIN.1 (A), R1.1, R3.1, R7.1, R11.1, R13.1
unnamed: C2.+, R2.1, R10.2, T1.D
unnamed: C4.2, C8.1, D3.C, D6.A, R4.2
unnamed: C5.2, D1.C, R3.2, R10.1, T1.G
unnamed: D1.A, R15.2, T1.S
unnamed: C9.2, L1.1, R2.2, R5.2, R12.2, R14.2
unnamed: C2.-, R9.2
unnamed: C8.2, MIDS.E, MIDS.S, TONE.3 (E)
unnamed: R8.2, T2.3 (E)
unnamed: C7.2, R4.1, TONE.1 (A)
unnamed: C3.1, C5.1, I.1, R1.2
unnamed: C10.2, R11.2, R14.1, T3.2 (B)
unnamed: OVERGAIN.3 (E), R8.1
unnamed: C12.+, OVERGAIN.2 (S)
unnamed: C1.1, R6.2, R9.1, T2.2 (B)
unnamed: C11.1, R12.1, T3.1 (C)
unnamed: C4.1, R5.1, R6.1, T2.1 (C)
unnamed: R13.2, T3.3 (E)
unnamed: MIDS.A, R7.2
unnamed: GAIN.3 (E), R15.1
unnamed: LEVEL.S, O.1
unnamed: C10.1, TONE.2 (S)
unnamed: C11.2, LEVEL.E
unnamed: C6.+, D4.C, L1.2
unnamed: D4.A, V.1

Board: 2 copper layers, 51.2 x 33.9 mm, 44 parts (0 on the bottom side), 25 nets.
